# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, RT_USING_ARM_LIBC, STM32F103xE
  c include: .;..\..\rt-thread\include;applications;.;board;board\CubeMX_Config\Inc;board\ports;..\..\libraries\HAL_Drivers;..\..\libraries\HAL_Drivers\config;packages\at24cxx-latest;packages\button-v1.0.1;packages\freemodbus-latest\modbus\include;packages\freemodbus-latest\modbus\rtu;packages\freemodbus-latest\modbus\ascii;packages\freemodbus-latest\port;packages\qsdk-latest\inc;..\..\rt-thread\libcpu\arm\common;..\..\rt-thread\libcpu\arm\cortex-m3;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\finsh;..\..\rt-thread\components\libc\compilers\armlibc;..\..\rt-thread\components\libc\compilers\common;..\..\rt-thread\components\net\at\include;..\..\rt-thread\components\utilities\ulog;..\..\libraries\STM32F1xx_HAL\CMSIS\Device\ST\STM32F1xx\Include;..\..\libraries\STM32F1xx_HAL\STM32F1xx_HAL_Driver\Inc;..\..\libraries\STM32F1xx_HAL\CMSIS\Include;..\..\qsdk-drivers;.
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Kernel
    ../../rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    ./applications/: m5310a.c
    applications/: buttonapp.c led.c main.c screen.c slave.c
  group Drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32f1xx_hal_msp.c
    ../../libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
    ../../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_soft_i2c.c drv_common.c
  group at24cxx
    packages/at24cxx-latest/: at24cxx.c
  group button_drive
    packages/button-v1.0.1/: button.c
  group FreeModbus
    packages/freemodbus-latest/modbus/functions/: mbfuncdiag.c mbutils.c mbfuncother.c mbfunccoils_m.c mbfuncdisc_m.c mbfuncholding_m.c mbfuncinput_m.c
    packages/freemodbus-latest/modbus/rtu/: mbcrc.c mbrtu_m.c
    packages/freemodbus-latest/port/: port.c portevent_m.c portserial_m.c porttimer_m.c user_mb_app_m.c
    packages/freemodbus-latest/modbus/: mb_m.c
    packages/freemodbus-latest/samples/: sample_mb_master.c
  group qsdk
    packages/qsdk-latest/src/: qsdk_nb.c qsdk_callback.c qsdk_onenet.c
  group cpu
    ../../rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../rt-thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../rt-thread/components/drivers/misc/: pin.c
    ../../rt-thread/components/drivers/serial/: serial.c
    ../../rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../rt-thread/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group libc
    ../../rt-thread/components/libc/compilers/armlibc/: libc.c mem_std.c stubs.c time.c
    ../../rt-thread/components/libc/compilers/common/: gmtime_r.c
  group AT
    ../../rt-thread/components/net/at/src/: at_utils.c at_cli.c at_client.c
  group Utilities
    ../../rt-thread/components/utilities/ulog/: ulog.c
    ../../rt-thread/components/utilities/ulog/backend/: console_be.c
  group STM32_HAL
    ../../libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    ../../libraries/STM32F1xx_HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal.c stm32f1xx_hal_cec.c stm32f1xx_hal_sram.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_i2c.c
